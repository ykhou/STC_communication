# Keil uVision project 18system_tft.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 18system_tft +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\hardware\chuankou;..\hardware\dongtai;..\hardware\flash;..\hardware\huanjing;..\hardware\led_key;..\hardware\paint;..\hardware\ruqing;..\hardware\touch_main;..\hardware\yaokong;..\hardware\zitai;..\main;..\system\bin;..\system\delay;..\system\iic;..\system\interrupt;..\system\spi;..\system\stc;..\tft_touch_sd\font;..\tft_touch_sd\touch;..\tft_touch_sd\tft;..\tft_touch_sd\txt;..\hardware\peizhi;..\hardware\communicat;..\hardware\phonebook
  group main
    ./: STARTUP.A51
    ../main/: main.c
  group system
    ../system/bin/: bin.c
    ../system/delay/: delay.c
    ../system/iic/: iic.c
    ../system/interrupt/: interrupt.c
    ../system/spi/: spi.c
  group hardware
    ../hardware/chuankou/: chuankou.c
    ../hardware/flash/: flash.c
    ../hardware/huanjing/: huanjing.c
    ../hardware/led_key/: led_key.c
    ../hardware/paint/: paint.c
    ../hardware/ruqing/: ruqing.c
    ../hardware/touch_main/: touch_main.c
    ../hardware/yaokong/: yaokong.c
    ../hardware/communicat/: communicat.c
    ../hardware/dongtai/: dongtai.c
    ../hardware/zitai/: cichang_hmc5883.c jiaosu_l3g4200.c jiasudu_adxl345.c
    ../hardware/phonebook/: phonebook.c
  group tft_touch
    ../tft_touch_sd/font/: font.c fontcheck.c
    ../tft_touch_sd/tft/: tft.C
    ../tft_touch_sd/touch/: touch.c
    ../tft_touch_sd/txt/: txt.c
